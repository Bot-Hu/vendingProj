# Keil uVision project GSM.uvprojx, settings and files
target GSM (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GSM +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\SPI;..\HARDWARE\SD;..\MALLOC;..\USMART;..\HARDWARE\FLASH;..\FATFS\src;..\FATFS\exfuns;..\TEXT;..\HARDWARE\24CXX;..\HARDWARE\TIMER;..\HARDWARE\TOUCH;..\HARDWARE\USART2;..\SIM900A;..\HARDWARE\IIC;..\ADC;..\HTTP;..\HARDWARE\USART3;..\HARDWARE\DHT11;..\CHANGE;..\HARDWARE\ULTRASONIC;..\HARDWARE\PWM;..\HARDWARE\MOTOR;..\HARDWARE\MENU;..\HARDWARE\BUTTON;..\HARDWARE\QR_Lib;..\HARDWARE\QR_main;..\HARDWARE\RTC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c pst.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/SD/: MMC_SD.C
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/TOUCH/: touch.c ctiic.c ott2001a.c ft5206.c gt9147.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/ULTRASONIC/: ultrasonic.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/RTC/: rtc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ../FATFS/src/: diskio.c ff.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group SIM900A
    ../SIM900A/: sim900a.c sim900a_call.c sim900a_init.c sim900_sms.c
  group README
    ../: README.TXT
  group ADC
    ../ADC/: stm32f10x_adc.c adc_rand.c sim900a_land.c
  group HTTP
    ../HTTP/: http.c
  group CHANGE
    ../CHANGE/: char_to_hex.c hex_to_char.c
  group MENU
    ../HARDWARE/MENU/: menu.c
  group BUTTON
    ../HARDWARE/BUTTON/: button.c
  group QR_Lib
    ../HARDWARE/QR_Lib/: qr_encode.c
  group QR_main
    ../HARDWARE/QR_main/: QRcode_main.c
